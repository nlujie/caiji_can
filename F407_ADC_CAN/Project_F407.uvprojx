# Keil uVision project Project_F407.uvprojx, settings and files
target STM32F407VGT6 ADC CAN (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") CLOCK(168000000) ELITTLE
  output: Project_F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx
  c include: .\Core;.\App;.\Drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ./Core/: startup_stm32f407xx.s system_stm32f407xx.c stm32f407_min.h timebase.c timebase.h
  group Drivers
    ./Drivers/: adc420_spi.c adc420_spi.h adc420_can.c adc420_can.h
  group Application
    ./App/: main.c adc420_app.c adc420_app.h
